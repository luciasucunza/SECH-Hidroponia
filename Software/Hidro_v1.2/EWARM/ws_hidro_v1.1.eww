<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\HIDRO_v1.1.ewp</path>
    </project>
    <batchBuild />
</workspace>
