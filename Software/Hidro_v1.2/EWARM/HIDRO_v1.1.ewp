# IAR project HIDRO_v1.1.ewp, settings and files
configuration HIDRO_v1.1 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476VE ST STM32L476VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L476xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../Drivers/CMSIS/Include; ../Middlewares/Third_Party/FatFs/src/drivers; ../Middlewares/Third_Party/FatFs/src; ..\Inc\API; ..\Inc\FATFS; ..\Inc\HIDRO
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HIDRO_v1.1.hex
  ILINK.IlinkOutputFile: HIDRO_v1.1.out
  ILINK.IlinkIcfFile: stm32l476xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/API
    ../Src/API/: api_dht11.c api_flash.c api_rtc.c
    ../Inc/API/: api_dht11.h api_flash.h api_rtc.h
  group Application/EWARM
    ./: startup_stm32l476xx.s
  group Application/HIDRO
    ../Src/HIDRO/: adc_sample.c button.c config_flash.c datetime.c di.c irrigation.c lcd.c ui.c utils.c weather.c
    ../Inc/HIDRO/: adc_sample.h button.h common.h config_flash.h datetime.h di.h irrigation.h lcd.h ui.h utils.h version.h weather.h
  group Application/User
    ../Src/: adc.c bsp_driver_sd.c dac.c dma.c fatfs.c fatfs_platform.c gpio.c iwdg.c main.c rtc.c sdmmc.c spi.c stm32l4xx_hal_msp.c stm32l4xx_it.c tim.c usart.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_sd.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_ll_sdmmc.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
